# Keil uVision project Com_BAT32A237_Standard.uvprojx, settings and files
target App_communication (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: BAT32A237KH40NB Cmsemicon
  pack: Cmsemicon.BAT32A237.1.0.8
  cpu: IRAM(0x20000000,0x03000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Com_BAT32A237_App +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=1,177,550
  c include: ..\Header;..\Driver\inc;..\UDS
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ../Source/: main.c ADC.c CAN.c Timer.c Uart.c interrupt.c GPIO.c Systerm_Init.c Flash.c AES128.c
  group Include
    ../Header/: ADC.h CAN.h Config.h Timer.h Uart.h GPIO.h System_Init.h Flash.h
  group UDS
    ../UDS/: can_api.c can_api.h datatype.h dtc.c dtc.h uds.c uds.h
  group Driver_inc
    ../Driver/inc/: bat32a237_basic_adc.h bat32a237_basic_can.h bat32a237_basic_clk.h bat32a237_basic_cmp.h bat32a237_basic_dac.h bat32a237_basic_div.h bat32a237_basic_dma.h bat32a237_basic_elc.h bat32a237_basic_flash.h bat32a237_basic_gpio.h bat32a237_basic_iica.h bat32a237_basic_intp.h bat32a237_basic_key.h bat32a237_basic_lin.h bat32a237_basic_pcbz.h bat32a237_basic_pga.h bat32a237_basic_rst.h bat32a237_basic_rtc.h bat32a237_basic_sci.h bat32a237_basic_tim4.h bat32a237_basic_tima.h bat32a237_basic_timb.h bat32a237_basic_timc.h bat32a237_basic_timm.h bat32a237_basic_wdt.h
  group Driver_scr
    ../Driver/src/: bat32a237_basic_adc.c bat32a237_basic_adc_user.c bat32a237_basic_can.c bat32a237_basic_can_user.c bat32a237_basic_clk.c bat32a237_basic_cmp.c bat32a237_basic_cmp_user.c bat32a237_basic_dac.c bat32a237_basic_div.c bat32a237_basic_dma.c bat32a237_basic_elc.c bat32a237_basic_flash.c bat32a237_basic_flash_user.c bat32a237_basic_gpio.c bat32a237_basic_iica.c bat32a237_basic_iica_user.c bat32a237_basic_intp.c bat32a237_basic_intp_user.c bat32a237_basic_key.c bat32a237_basic_key_user.c bat32a237_basic_lin.c bat32a237_basic_pcbz.c bat32a237_basic_pga.c bat32a237_basic_retarget.c bat32a237_basic_rst.c bat32a237_basic_rtc.c bat32a237_basic_rtc_user.c bat32a237_basic_sci.c bat32a237_basic_sci_user.c bat32a237_basic_tim4.c bat32a237_basic_tim4_user.c bat32a237_basic_tima.c bat32a237_basic_tima_user.c bat32a237_basic_timb.c bat32a237_basic_timb_user.c bat32a237_basic_timc.c bat32a237_basic_timc_user.c bat32a237_basic_timm.c bat32a237_basic_timm_user.c bat32a237_basic_wdt.c bat32a237_basic_wdt_user.c
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.4.0, Device:ISR 1.0.0, Device:Startup 1.0.0
